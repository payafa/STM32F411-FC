# Keil uVision project FlightControl.uvprojx, settings and files
target FC (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: FlightControl
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c include: ..\FWLIB\CMSIS\Core;..\FWLIB\CMSIS\Driver\Startup;..\FWLIB\CMSIS\Driver\STM32F4xx;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\FreeRTOS\inc;..\FreeRTOS;..\TASK;..\DRIVER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../FWLIB/CMSIS/Core/: arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../FWLIB/CMSIS/Driver/Startup/: startup_stm32f411xe.s
    ../FWLIB/CMSIS/Driver/STM32F4xx/: stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c system_stm32f4xx.c
  group USER
    ./: main.c
  group FreeRTOS
    ../FreeRTOS/port/: heap_4.c port.c
    ../FreeRTOS/src/: event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/: FreeRTOSConfig.h
  group TASK
    ../TASK/: radioLink.c atkpRx.c stabilizer.c atkpTx.c
  group COMMUNITY
    ../COMMUNITY/: community.c
  group DRIVER
    ../DRIVER/: UART2.c BMP280.c I2C.c MPU9250.c
